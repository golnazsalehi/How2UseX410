options:
  parameters:
    author: wcsng-101
    generate_options: qt_gui
    id: x410_4rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 4.0e9
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: int(samp_rate_rx)*5
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: samp_rate_rx
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /mnt/ramdisk/uhd_ofdm_rx2.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /mnt/ramdisk/uhd_ofdm_rx3.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /mnt/ramdisk/uhd_ofdm_rx1.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /mnt/ramdisk/uhd_ofdm_rx4.dat
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0_0_0_0_0_0
  id: blocks_head
  parameters:
    num_items: num_samples
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_rx
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: center_freq
    center_freq1: center_freq
    center_freq2: center_freq
    center_freq3: center_freq
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.2"'
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate_rx
    sd_spec0: A:0 A:1 B:0 B:1
    start_time: '1'
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0_0_0_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_head_0_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_head_0_0_0_0_0_0, '0', blocks_file_sink_0_0_0_0_1, '0']
- [blocks_head_0_0_0_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', blocks_head_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '1', blocks_head_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '1', qtgui_sink_x_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '2', blocks_head_0_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '2', qtgui_sink_x_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '3', blocks_head_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '3', qtgui_sink_x_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
